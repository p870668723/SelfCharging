# Keil uVision project STM32F103C.uvproj, settings and files
target STM32F103RBT6 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: STM32F103C
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD
  c include: ..\Mylib;..\Libraries;..\CM3;..\User;..\User\debug;..\MPU6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CM3
    ../CM3/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Libraries
    ../Libraries/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_spi.c
  group Mylib
    ../Mylib/: led.c encoder.c pwm.c delay.c ad.c flash.c key.c Iwdg.c DEBUG.c control.c UART.c BSP.c beep.c stmflash.c ldc1000.c time.c
    ../Libraries/: stm32f10x_dma.c
  group User
    ../User/: main.c stm32f10x_it.c app.c
  group IMU
    ../MPU6050/: mpu6050_driver.c mpu6050_i2c.c mpu6050_interrupt.c mpu6050_process.c
    ../Mylib/: HMC5883L.c

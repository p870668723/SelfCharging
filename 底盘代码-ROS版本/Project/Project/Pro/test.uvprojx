# Keil uVision project test.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: test +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,MPU6050
  c include: ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\ucosii\core;..\..\ucosii\port;..\..\USER\INC;..\..\Slamware;..\..\eMPL;..\..\Libraries\CMSIS\ST\STM32F4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK_STARTUP
    ./: startup_stm32f4xx.s
  group USER
    ../../USER/SRC/: stm32f4xx_it.c can1.c timer.c main.cpp bankCommon.c cmatrix.c myfilter.c mymath.c systick.c I2C.c ks103.c dbus.c pidControl.c usart1.c
  group STMLIB
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_can.c
  group UCOSII_PORT
    ../../ucosii/port/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group UCOSII_CORE
    ../../ucosii/core/: ucos_ii.h app_hooks.c os_cfg.h os_cfg_r.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group DISPLAY
    ../../USER/SRC/: lcd12864s.c oled.c oledlib.c
  group CMSIS
    ../../USER/SRC/: system_stm32f4xx.c
  group Sensor
    ../../USER/SRC/: ultrasonic.c board.c
  group Motor
    ../../USER/SRC/: robotmodel.c
  group IMU
    ../../eMPL/: imu.c inv_mpu.c mpu6050.c mpu_i2c.c kalman.c
  group ::Device
    RTE/Device/STM32F407VG/: RTE_Device.h startup_stm32f40_41xxx.s system_stm32f4xx.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.3.0
